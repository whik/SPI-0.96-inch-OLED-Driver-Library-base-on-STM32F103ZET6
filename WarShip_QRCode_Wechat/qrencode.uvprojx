# Keil uVision project qrencode.uvprojx, settings and files
target QRENCODE (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: qrencode +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\SYSTEM\DELAY;.\SYSTEM\SYS;.\SYSTEM\USART;.\USER;.\QRENCODE;.\HARDWARE\BEEP;.\HARDWARE\EXTI;.\HARDWARE\KEY;.\HARDWARE\LCD;.\HARDWARE\LED;.\HARDWARE\TIMER;.\HARDWARE\TPAD;.\HARDWARE\WDG;.\HARDWARE\FUNCTION
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CORE
    ./USER/: startup_stm32f10x_hd.s
  group USER
    ./USER/: main.c
  group HARDWARE
    ./HARDWARE/FUNCTION/: function.c
    ./HARDWARE/BEEP/: beep.c
    ./HARDWARE/EXTI/: exti.c
    ./HARDWARE/KEY/: key.c
    ./HARDWARE/LCD/: ILI93xx.c
    ./HARDWARE/LED/: led.c
    ./HARDWARE/TIMER/: timer.c
    ./HARDWARE/TPAD/: tpad.c
    ./HARDWARE/WDG/: wdg.c
  group QRCODE
    ./QRENCODE/: QR_Encode.c bitstream.c mask.c mmask.c mqrspec.c qrencode.c qrinput.c qrspec.c rscode.c split.c
  group SYSTEM
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/sys/: sys.c
    ./SYSTEM/usart/: usart.c
